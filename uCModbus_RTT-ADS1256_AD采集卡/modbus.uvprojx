# Keil uVision project modbus.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: modbus +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\User\Option;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\modbus\Cfg;.\modbus\Ports;.\modbus\Source;.\modbus\uC-CPU;.\Modbus\OS;.\rt-thread-3.1.3\include;.\rt-thread-3.1.3\include\libc;.\rt-thread-3.1.3\components\finsh;.\rt-thread-3.1.3\bsp\stm32f103-blink\RTE\_stm32f103-led;.\flash
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./Startup/Startup/: startup_stm32f10x_md.s
  group user
    ./User/: main.c stm32f10x_sys.c ADS1256.c rtconfig.h task.c DataProcessing.C
    ./rt-thread-3.1.3/bsp/: board.c
    ./flash/: flash.c
  group stdlib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_fsmc.c
    ./Libraries/CMSIS/: system_stm32f10x.c
  group uC-Modbus
    ./Modbus/OS/: mb_app.c
    ./Modbus/Ports/: MB_BSP.c
    ./Modbus/Cfg/: MB_DATA.C
    ./Modbus/Source/: MB.C MB_UTIL.C MBS_CORE.C
  group uC-CPU
    ./Modbus/uC-CPU/: cpu.h cpu_a.asm
  group rtt/source
    ./rt-thread-3.1.3/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtt/ports
    ./rt-thread-3.1.3/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S

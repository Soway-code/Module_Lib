# IAR project CapacitiveSensor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072CB ST STM32L072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L072xx
  ICCARM.CCIncludePath2: ..\Source\APP\inc; ..\Source\BSP\inc; ..\Source\CMSIS\inc; ..\Source\FWLIB\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CapacitiveSensor.bin
  ILINK.IlinkOutputFile: CapacitiveSensor.out
  ILINK.IlinkIcfFile: CapacitiveSensor.icf
  ILINK.IlinkAdditionalLibs: C:\Users\macanlin\Desktop\lib生成\iar\Mindray_V1_1_7(4_dot_Collect) -11-10 -boot 0x08003000\Source\APP\PCapDistance.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; STM32L072xx
  ICCARM.CCOptLevel: 2
  group APP
    ../Source/APP/: DataOutput.c main.c modbus.c modbus_ascii.c Picocap.c spi_bsp.c stm32l0_adc_app.c stm32l0_dac_app.c stm32l0_eeprom_app.c stm32l0_timer_app.c stm32l0_usart_app.c TypeConvert.c User_Selection.c
  group BSP
    ../Source/BSP/: SoftSpi.c stm32l0_adc.c stm32l0_dac.c stm32l0_eeprom.c stm32l0_timer.c stm32l0_usart.c stm32l0xx_it.c
  group CMSIS
    ../Source/CMSIS/inc/: startup_stm32l072xx.s
    ../Source/CMSIS/: system_stm32l0xx.c
  group FWLIB
    ../Source/FWLIB/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c

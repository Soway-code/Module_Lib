# Keil uVision project GD32F103C_EVAL.uvprojx, settings and files
target GD32F103C_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin !L --output Exe/GD103.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\;..\CMSIS\GD\GD32F10x\Include;..\GD32F10x_standard_peripheral\Include;..\Utilities;..\CMSIS;..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../: main.c gd32f10x_it.c
  group CMSIS
    ../CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ../CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group Doc
    ../: readme.txt
  group APP
    ../APP/Src/: usart.c GD_FlashApp.c modbus.c UserApp.c Baseincludes.c GD32F103_Systick.C DmaConfig.c ADC.c algorithm.c calculate.c mpu6050.c SimulateIic.c

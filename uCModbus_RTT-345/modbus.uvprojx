# Keil uVision project modbus.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: modbus +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\User\Option;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\modbus\Cfg;.\modbus\Ports;.\modbus\Source;.\modbus\uC-CPU;.\Modbus\OS;.\rt-thread-3.1.3\include;.\rt-thread-3.1.3\include\libc;.\rt-thread-3.1.3\components\finsh;.\rt-thread-3.1.3\bsp\stm32f103-blink\RTE\_stm32f103-led;.\flash;.\APP\inc;.\BSP\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./Startup/Startup/: startup_stm32f10x_md.s
  group user
    ./User/: main.c stm32f10x_sys.c rtconfig.h task.c
    ./rt-thread-3.1.3/bsp/: board.c
    ./flash/: Flash_app.c
  group stdlib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c
    ./Libraries/CMSIS/: system_stm32f10x.c
  group uC-Modbus
    ./Modbus/OS/: mb_app.c
    ./Modbus/Ports/: MB_BSP.c
    ./Modbus/Cfg/: MB_DATA.C
    ./Modbus/Source/: MB.C MB_UTIL.C MBS_CORE.C
  group uC-CPU
    ./Modbus/uC-CPU/: cpu.h cpu_a.asm
  group rtt/source
    ./rt-thread-3.1.3/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtt/ports
    ./rt-thread-3.1.3/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group BSP
    ./BSP/: AT24cxx.c SoftwareIIC.c flash.c spi.c rtc.c
  group APP
    ./APP/: algorithm.c LoadTask.c Analog.c iwdg.c ADXL345.c
